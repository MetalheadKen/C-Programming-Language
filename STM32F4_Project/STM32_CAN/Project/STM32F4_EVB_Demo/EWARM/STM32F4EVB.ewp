# IAR project STM32F4EVB.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STM32F4_EVB; STM32F40XX; USE_STDPERIPH_DRIVER; USE_ULPI_PHY
  ICCARM.CCIncludePath2: ..\; ..\inc\; ..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\Libraries\STM32F4x7_ETH_Driver\inc; ..\..\..\Libraries\STM32_USB_Device_Library\Class\cdc\inc; ..\..\..\Libraries\STM32_USB_Device_Library\Core\inc; ..\..\..\Libraries\STM32_USB_OTG_Driver\inc; ..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\Utilities\STM32_EVAL\STM32F4_EVB; ..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\Utilities\Third_Party\lwip_v1.3.2\port\STM32F4x7\; ..\..\..\Utilities\Third_Party\lwip_v1.3.2\port\STM32F4x7\Standalone; ..\..\..\Utilities\Third_Party\lwip_v1.3.2\src\include; ..\..\..\Utilities\Third_Party\lwip_v1.3.2\src\include\ipv4; ..\..\..\Utilities\Third_Party\lwip_v1.3.2\src\include\lwip
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F4EVB.srec
  ILINK.IlinkOutputFile: STM32F4EVB.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f40xx.s
    ../src/: system_stm32f4xx.c
  group FWLib
    ../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group STM32F4_EVB
    ../../../Utilities/STM32_EVAL/STM32F4_EVB/: stm32f4_evb.c stm32f4_evb_audio_codec.c stm32f4_evb_fsmc_psram.c stm32f4_evb_i2c_ee.c stm32f4_evb_i2c_tsc.c stm32f4_evb_lcd.c stm32f4_evb_sdio_sd.c
  group User
    ../src/: main.c stm32f4xx_it.c
