# IAR project STM32_FATFS_SD.ewp, settings and files
configuration STM322xG-EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207ZG ST STM32F207ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F2XX; USE_STM322xG_EVAL
  ICCARM.CCIncludePath2: ..; ..\Devices\STM32F2xx; ..\..\..\Libraries\STM32_USB_HOST_Library\Core\inc; ..\..\..\Libraries\STM32_USB_HOST_Library\Class\MSC\inc; ..\..\..\Libraries\STM32_USB_OTG_Driver\inc; ..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc; ..\..\..\Libraries\CMSIS\Device\ST\STM32F2xx\Include; ..\..\..\Utilities\STM32_EVAL; ..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\Utilities\STM32_EVAL\STM322xG_EVAL; ..\..\..\Utilities\Third_Party\fat_fs\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Config
  OBJCOPY.OOCOutputFile: STM32_FatFS_Example_V1.0.0RC2.bin
  ILINK.IlinkOutputFile: STM322xG-EVAL.out
  ILINK.IlinkIcfFile: stm32f2xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM324xG-EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX; USE_STM324xG_EVAL
  ICCARM.CCIncludePath2: ..; ..\Devices\STM32F4xx; ..\..\..\Libraries\STM32_USB_HOST_Library\Core\inc; ..\..\..\Libraries\STM32_USB_HOST_Library\Class\MSC\inc; ..\..\..\Libraries\STM32_USB_OTG_Driver\inc; ..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\Utilities\STM32_EVAL; ..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\Utilities\STM32_EVAL\STM3240_41_G_EVAL; ..\..\..\Utilities\Third_Party\fat_fs\inc
  ILINK.IlinkOutputFile: STM324xG-EVAL.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
configuration STM3210E_EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCIncludePath2: ..; ..\Devices\STM32F1xx; ..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include; ..\..\..\Utilities\STM32_EVAL; ..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\Utilities\STM32_EVAL\STM3210E_EVAL; ..\..\..\Utilities\Third_Party\fat_fs\inc
  ILINK.IlinkOutputFile: STM3210E-EVAL.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  group Demo/Devices/STM32F1xx
    ../Devices/STM32F1xx/: bsp.c startup_stm32f10x_hd.s system_stm32f10x.c
  group Demo/Devices/STM32F1xx/STM3210E_EVAL
    ../../../Utilities/STM32_EVAL/STM3210E_EVAL/: stm3210e_eval.c stm3210e_eval_lcd.c stm3210e_eval_sdio_sd.c
  group Demo/Devices/STM32F1xx/STM32F10x_StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_spi.c
  group Demo/Devices/STM32F2xx
    ../Devices/STM32F2xx/: bsp.c startup_stm32f2xx.s system_stm32f2xx.c
  group Demo/Devices/STM32F2xx/STM322xG-EVAL
    ../../../Utilities/STM32_EVAL/STM322xG_EVAL/: stm322xg_eval.c stm322xg_eval_lcd.c stm322xg_eval_sdio_sd.c
  group Demo/Devices/STM32F2xx/STM32F2xx_StdPeriph_Driver
    ../../../Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_dma.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_rcc.c stm32f2xx_sdio.c stm32f2xx_tim.c
  group Demo/Devices/STM32F4xx
    ../Devices/STM32F4xx/: bsp.c startup_stm32f4xx.s system_stm32f4xx.c
  group Demo/Devices/STM32F4xx/STM324xG-EVAL
    ../../../Utilities/STM32_EVAL/STM3240_41_G_EVAL/: stm324xg_eval.c stm324xg_eval_lcd.c stm324xg_eval_sdio_sd.c
  group Demo/Devices/STM32F4xx/STM32F4xx_StdPeriph_Driver
    ../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_tim.c
  group Demo/User
    ../: fatfs_drv.c main.c stm32xxx_it.c
  group Utilities/Common
    ../../../Utilities/STM32_EVAL/Common/: lcd_log.c
  group Utilities/FAT_FS
    ../../../Utilities/Third_Party/fat_fs/src/option/: ccsbcs.c
    ../../../Utilities/Third_Party/fat_fs/src/: ff.c
