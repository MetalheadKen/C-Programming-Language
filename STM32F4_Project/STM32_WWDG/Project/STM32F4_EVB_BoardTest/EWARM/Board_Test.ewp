# IAR project Board_Test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207IG ST STM32F207IG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STM32F4_EVB; STM32F40XX; USE_STDPERIPH_DRIVER; USE_USB_OTG_HS; USE_ULPI_PHY
  ICCARM.CCIncludePath2: ..\; ..\inc\; ..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\Libraries\STM32F4x7_ETH_Driver\inc; ..\..\..\Libraries\STM32_USB_Device_Library\Class\cdc\inc; ..\..\..\Libraries\STM32_USB_Device_Library\Core\inc; ..\..\..\Libraries\STM32_USB_OTG_Driver\inc; ..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\Utilities\STM32_EVAL\STM32F4_EVB; ..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\Utilities\Third_Party\lwip_v1.3.2\port\STM32F4x7\; ..\..\..\Utilities\Third_Party\lwip_v1.3.2\port\STM32F4x7\Standalone; ..\..\..\Utilities\Third_Party\lwip_v1.3.2\src\include; ..\..\..\Utilities\Third_Party\lwip_v1.3.2\src\include\ipv4; ..\..\..\Utilities\Third_Party\lwip_v1.3.2\src\include\lwip
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Board_Test.srec
  ILINK.IlinkOutputFile: Board_Test.out
  ILINK.IlinkIcfFile: ..\..\Config\stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f40xx.s
    ../src/: system_stm32f4xx.c
  group Common
    ../../../Utilities/STM32_EVAL/Common/: lcd_log.c
  group LwIP
    ../../../Utilities/Third_Party/lwip_v1.3.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../Utilities/Third_Party/lwip_v1.3.2/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../../Utilities/Third_Party/lwip_v1.3.2/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    ../../../Utilities/Third_Party/lwip_v1.3.2/src/netif/: etharp.c loopif.c slipif.c
    ../../../Utilities/Third_Party/lwip_v1.3.2/port/STM32F4x7/Standalone/: ethernetif.c
  group STD_FWLib
    ../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group STM32F4_EVB
    ../../../Utilities/STM32_EVAL/STM32F4_EVB/: stm32f4_evb.c stm32f4_evb_audio_codec.c stm32f4_evb_fsmc_psram.c stm32f4_evb_i2c_ee.c stm32f4_evb_i2c_gsensor.c stm32f4_evb_i2c_tsc.c stm32f4_evb_lcd.c stm32f4_evb_sdio_sd.c
  group STM32F4x7_ETH_Driver
    ../../../Libraries/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group USB Device
    ../../../Libraries/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
    ../../../Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group USB Driver
    ../../../Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group User
    ../src/: audio_sample.c main.c stm32f4xx_it.c
  group User_Ethernet
    ../src/: netconf.c stm32f4x7_eth_bsp.c tcp_echoclient.c
  group User_USB
    ../src/: usb_bsp.c usbd_cdc_vcp.c usbd_desc.c usbd_usr.c
